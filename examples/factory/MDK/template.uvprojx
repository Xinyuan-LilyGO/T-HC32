# Keil uVision project template.uvprojx, settings and files
target template_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: template +hex
  c flags: Optim=3 OneElfS=1 uC99=1
  c define: HC32L110Bxxx,
  c include: ..\source;..\..\..\driver\inc;..\driver\inc;..\common;..\u8g2\csrc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l110.s
    ../driver/src/: interrupts_hc32l110.c
    ../common/: system_hc32l110.c
  group source
    ../source/: main.c
  group driver
    ../driver/src/: adc.c clk.c ddl.c gpio.c i2c.c
  group README
    ../: readme.txt
  group u8x8
    ../u8g2/csrc/: u8x8_u16toa.c u8x8_u8toa.c u8x8_string.c u8x8_setup.c u8x8_selection_list.c u8x8_message.c u8x8_input_value.c u8x8_gpio.c u8x8_fonts.c u8x8_display.c u8x8_debounce.c u8x8_d_ssd1306_128x64_noname.c u8x8_capture.c u8x8_cad.c u8x8_byte.c u8x8_8x8.c u8log_u8x8.c u8log.c mui.c u8x8_d_ssd1306_64x32.c
software components: CMSIS:CORE 4.1.0
