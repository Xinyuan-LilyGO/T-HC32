<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\adc_tim2_scan_irq_sw.ewp</path>
  </project>
  <batchBuild/>
</workspace>


