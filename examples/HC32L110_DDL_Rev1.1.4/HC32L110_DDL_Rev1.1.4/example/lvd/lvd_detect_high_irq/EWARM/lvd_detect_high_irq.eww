<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lvd_detect_high_irq.ewp</path>
  </project>
  <batchBuild/>
</workspace>


