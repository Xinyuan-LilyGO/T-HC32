# Keil uVision project uart_master.uvprojx, settings and files
target uart_master_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: uart_master
  c flags: Optim=1 OneElfS=1
  c define: HC32L110Bxxx,
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l110.s
    ../../../../mcu/common/: system_hc32l110.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: ddl.c interrupts_hc32l110.c clk.c uart.c bt.c gpio.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
